IMAGE_INSTALL_append = " libdrm-tests libdrm-kms"
