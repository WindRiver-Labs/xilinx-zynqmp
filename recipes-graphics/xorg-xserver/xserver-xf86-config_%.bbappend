FILESEXTRAPATHS_prepend_xilinx-zynqmp := "${THISDIR}/${PN}:"
