require linux-yocto-fitimage-xilinx-zynqmp.inc
