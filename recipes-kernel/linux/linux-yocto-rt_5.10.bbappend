require linux-yocto-xilinx-zynqmp.inc

KBRANCH_xilinx-zynqmp  = "v5.10/standard/preempt-rt/sdkv5.10/xlnx-soc"
