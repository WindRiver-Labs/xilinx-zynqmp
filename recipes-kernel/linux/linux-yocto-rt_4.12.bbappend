
require linux-yocto-xilinx-zynqmp.inc
KBRANCH_xilinx-zynqmp  = "standard/preempt-rt/xilinx/sdk2017-04/xilinx-zynqmp"
