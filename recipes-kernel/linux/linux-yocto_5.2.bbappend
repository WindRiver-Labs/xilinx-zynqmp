require linux-yocto-xilinx-zynqmp.inc

KBRANCH_xilinx-zynqmp  = "v5.2/standard/xlnx-soc"

LINUX_VERSION_xilinx-zynqmp ?= "5.2.x"
