
require linux-yocto-xilinx-zynqmp.inc
KBRANCH_xilinx-zynqmp  = "v4.18/standard/preempt-rt/xilinx/sdk2018-03/xilinx-zynqmp"
