require linux-yocto-xilinx-zynqmp.inc

KBRANCH_xilinx-zynqmp  = "v5.10/standard/sdkv5.4/xlnx-soc"

LINUX_VERSION_xilinx-zynqmp ?= "5.10.x"
