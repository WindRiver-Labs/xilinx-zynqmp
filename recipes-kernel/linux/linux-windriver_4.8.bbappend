require linux-windriver-xilinx-zynqmp.inc
