
require linux-yocto-xilinx-zynqmp.inc
KBRANCH_xilinx-zynqmp  = "standard/xilinx/sdk2017-04/xilinx-zynqmp"
