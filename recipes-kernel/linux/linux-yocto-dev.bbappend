require linux-yocto-xilinx-zynqmp.inc 

KBRANCH_xilinx-zynqmp  = "standard/xlnx-soc"
