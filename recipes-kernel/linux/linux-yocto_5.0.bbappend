require linux-yocto-xilinx-zynqmp.inc

KBRANCH_xilinx-zynqmp  = "v5.0/standard/xilinx-zynqmp"
