require linux-yocto-xilinx-zynqmp.inc

KBRANCH_xilinx-zynqmp  = "v5.4/standard/xlnx-soc"

LINUX_VERSION_xilinx-zynqmp ?= "5.4.x"
